TYPE ST_POSITION :
STRUCT
	rotation  : INT;
	extension : INT;
	lift      : INT;
	grip      : INT; 
END_STRUCT
END_TYPE
