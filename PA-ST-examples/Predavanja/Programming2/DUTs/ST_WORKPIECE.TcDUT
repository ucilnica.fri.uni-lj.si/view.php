TYPE ST_WORKPIECE :
STRUCT
	id : INT;
	recipe : ST_RECIPE;
END_STRUCT
END_TYPE
