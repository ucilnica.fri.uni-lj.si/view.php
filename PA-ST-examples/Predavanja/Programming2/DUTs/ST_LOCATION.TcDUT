TYPE ST_LOCATION :
STRUCT
	workpiece : ST_WORKPIECE;
	occupied  : BOOL;
	isDone    : BOOL;
END_STRUCT
END_TYPE
