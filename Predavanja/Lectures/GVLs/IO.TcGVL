{attribute 'qualified_only'}
VAR_GLOBAL
	ButtonRed AT %I*: BOOL;
	LEDRed AT %Q*: BOOL;
END_VAR
